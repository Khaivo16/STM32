# Keil uVision project ENC28J60.uvprojx, settings and files
target STM32H7 Configuration (ARM-ADS)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: H7Cpp
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H7xx,STM32H750xx
  c misc: --cpp
  c include: ..\..\Inc;..\..\Drivers\STM32H7xx_HAL_Driver\Inc;..\..\Drivers\STM32H7xx_HAL_Driver\Inc\Legacy;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\..\SYSTEM\delay;..\..\SYSTEM\sys;..\..\SYSTEM\usart;..\ETH_MQTT;..\..\HARDWARE;..\..\HARDWARE\DHT11;..\..\HARDWARE\TM1637Display;..\..\HARDWARE\STM32Encoder-master\src;..\..\HARDWARE\UIPEthernet\utility;..\..\HARDWARE\UIPEthernet;..\..\HARDWARE\MQTT\arduino-mqtt-master\src;..\..\HARDWARE\MQTT\arduino-mqtt-master\src\lwmqtt
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h750xx.s
  group LIB
    ../../SYSTEM/: PinMap.c H7Cpp.lib
  group HARDWARE
    ../../HARDWARE/DHT11/: DHT11.cpp
    ../../HARDWARE/TM1637Display/: TM1637Display.cpp
    ../../HARDWARE/UIPEthernet/utility/: clock-arch.c uip.c uip_arp.c uip_timer.c Enc28J60Network.cpp mempool.cpp uip_debug.cpp
    ../../HARDWARE/UIPEthernet/: Dhcp.cpp Dns.cpp UIPClient.cpp UIPEthernet.cpp UIPServer.cpp UIPUdp.cpp
  group MQTT
    ../../HARDWARE/MQTT/arduino-mqtt-master/src/lwmqtt/: client.c helpers.c packet.c string.c
    ../../HARDWARE/MQTT/arduino-mqtt-master/src/: MQTTClient.cpp
  group Application/User
    ./: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c
