# Keil uVision project TFT.uvprojx, settings and files
target STM32H7 Configuration (ARM-ADS)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: H7Cpp
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H7xx,STM32H750xx,USE_FULL_LL_DRIVER
  c misc: --cpp
  c include: ..\..\Inc;..\..\Drivers\STM32H7xx_HAL_Driver\Inc;..\..\Drivers\STM32H7xx_HAL_Driver\Inc\Legacy;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\..\SYSTEM\delay;..\..\SYSTEM\sys;..\..\SYSTEM\usart;..\Blink;..\..\HARDWARE;..\..\HARDWARE\DHT11;..\..\HARDWARE\TM1637Display;..\..\HARDWARE\Adafruit_GFX_AS;..\..\HARDWARE\Adafruit_GFX_AS\utility;..\..\HARDWARE\Adafruit_ILI9341;..\..\HARDWARE\Adafruit_ILI9341\utility;..\..\HARDWARE\Adafruit_ILI9341_DMA
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h750xx.s
  group LIB
    ../../SYSTEM/: PinMap.c H7Cpp.lib
  group HARDWARE
    ../../HARDWARE/DHT11/: DHT11.cpp
    ../../HARDWARE/TM1637Display/: TM1637Display.cpp
  group TFT
    ../../HARDWARE/Adafruit_GFX_AS/: Font7s.c Font16.c Font32.c Font64.c Adafruit_GFX_AS.cpp
    ../../HARDWARE/Adafruit_GFX_AS/utility/: glcdfont.c Adafruit_GFX.cpp
    ../../HARDWARE/Adafruit_ILI9341/: Adafruit_ILI9341.cpp
    ../../HARDWARE/Adafruit_ILI9341_DMA/: Adafruit_ILI9341_DMA.cpp
  group Application/User
    ./: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c
