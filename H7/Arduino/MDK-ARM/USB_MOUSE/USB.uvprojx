# Keil uVision project USB.uvprojx, settings and files
target STM32H7 Configuration (ARM-ADS)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: F4Cpp +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H7xx,STM32H750xx,USE_FULL_LL_DRIVER,USBD_USE_HID_COMPOSITE,USBCON
  c misc: --cpp11
  c include: ..\..\Inc;..\..\Drivers\STM32H7xx_HAL_Driver\Inc;..\..\Drivers\STM32H7xx_HAL_Driver\Inc\Legacy;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\..\SYSTEM\delay;..\..\SYSTEM\sys;..\..\SYSTEM\usart;..\USB_KEYBOARD;..\..\HARDWARE;..\..\HARDWARE\DHT11;..\..\HARDWARE\TM1637Display;..\..\HARDWARE\USB;..\..\HARDWARE\USB\cdc;..\..\HARDWARE\USB\hid;..\..\Drivers\STM32_USB_Device_Library\Core\Inc;..\..\HARDWARE\Keyboard\src;..\..\HARDWARE\Mouse\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h750xx.s
  group Drivers/STM32H7xx_HAL_Driver
    ../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c
  group LIB
    ../../SYSTEM/: PinMap.c H7Cpp.lib
  group HARDWARE
    ../../HARDWARE/DHT11/: DHT11.cpp
    ../../HARDWARE/TM1637Display/: TM1637Display.cpp
  group USB
    ../../HARDWARE/USB/: usbd_conf.c usbd_desc.c usbd_ep_conf.c usbd_if.c USBSerial.cpp
    ../../HARDWARE/USB/cdc/: cdc_queue.c usbd_cdc.c usbd_cdc_if.c
    ../../Drivers/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../HARDWARE/USB/hid/: usbd_hid_composite.c usbd_hid_composite_if.c
    ../../HARDWARE/Keyboard/src/: Keyboard.cpp
    ../../HARDWARE/Mouse/src/: Mouse.cpp
  group Application/User
    ./: stm32h7xx_hal_msp.c stm32h7xx_it.c main.c
