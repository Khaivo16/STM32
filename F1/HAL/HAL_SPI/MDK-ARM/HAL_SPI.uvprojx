# Keil uVision project HAL_SPI.uvprojx, settings and files
target STM32F1 Configuration (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F1
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32F103xB,STM32F1xx,
  c include: ..\Inc;..\Drivers\STM32F1xx_HAL_Driver\Inc;..\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\MDK-ARM;..\HARDWARE\ADC;..\HARDWARE\DS1307;..\HARDWARE\EXTI;..\HARDWARE\IIC;..\HARDWARE\Pwm;..\HARDWARE\timer_base;..\HARDWARE\SPI;..\SYSTEM\usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_pwr.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xg.s
  group Application/User
    ../SYSTEM/sys/: sys.c
    ../Src/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c
  group Handware
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/DS1307/: ds1307.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/Pwm/: pwm.c
    ../HARDWARE/timer_base/: timer.c
    ../HARDWARE/SPI/: spi.c
    ../SYSTEM/usart/: usart.c
