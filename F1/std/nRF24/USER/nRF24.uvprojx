# Keil uVision project nRF24.uvprojx, settings and files
target SPI (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ABC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=5 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\HARDWARE\LED;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\HARDWARE\EXTI;..\HARDWARE\UART;..\..\PWM\HARDWARE\PWM;..\HARDWARE\TIMER;..\HARDWARE\CAPTURE;..\HARDWARE\I2C;..\HARDWARE\SPI;..\HARDWARE\NRF24l01
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group HARDWARE
    ../HARDWARE/LED/: LED.c
    ../HARDWARE/EXTI/: EXTI.c
    ../HARDWARE/UART/: uart.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/CAPTURE/: INPUT_CAPTURE.c
    ../HARDWARE/SPI/: SPI.c
    ../HARDWARE/NRF24l01/: nrf24l01.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group FWARE
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_i2c.c stm32f10x_spi.c
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
