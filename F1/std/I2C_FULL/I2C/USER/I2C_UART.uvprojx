# Keil uVision project I2C_UART.uvprojx, settings and files
target TEMP (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TEMP +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\DHT11;..\HARDWARE\IIC;..\HARDWARE\DS1307;..\HARDWARE\LCD_I2C
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group HARDWARE
    ../HARDWARE/LED/: LED.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/DS1307/: ds1307.c
    ../HARDWARE/LCD_I2C/: LCD_I2C.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_i2c.c
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
