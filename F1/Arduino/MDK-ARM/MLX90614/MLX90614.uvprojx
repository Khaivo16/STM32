# Keil uVision project MLX90614.uvprojx, settings and files
target STM32F1 Configuration (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F4Cpp
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32F103xB,STM32F1xx,
  c misc: --cpp11
  c include: ..\..\Inc;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\SYSTEM\delay;..\..\SYSTEM\sys;..\..\SYSTEM\usart;..\Blink;..\..\HARDWARE;..\..\HARDWARE\DHT11;..\..\HARDWARE\TM1637Display;..\..\HARDWARE\Wire\src;..\..\HARDWARE\Arduino-MAX30100-master\src;..\..\HARDWARE\Adafruit-MLX90614-Library-master;..\..\HARDWARE\Adafruit-MLX90614-Library-master\MLX90614-0.1.5\MLX90614-0.1.5\src;..\..\HARDWARE\Adafruit-MLX90614-Library-master\AsyncDelay-1.1.2\AsyncDelay-1.1.2\src;..\..\HARDWARE\Adafruit-MLX90614-Library-master\SoftWire-2.0.9\SoftWire-2.0.9\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xg.s
  group LIB
    ../../SYSTEM/: F1Cpp.lib PinMap.c
  group HARDWARE
    ../../HARDWARE/DHT11/: DHT11.cpp
    ../../HARDWARE/TM1637Display/: TM1637Display.cpp
    ../../HARDWARE/Adafruit-MLX90614-Library-master/MLX90614-0.1.5/MLX90614-0.1.5/src/: MLX90614.cpp
    ../../HARDWARE/Adafruit-MLX90614-Library-master/SoftWire-2.0.9/SoftWire-2.0.9/src/: SoftWire.cpp
  group Wire
    ../../HARDWARE/Wire/src/: twi.c Wire.cpp
  group MAX30100
    ../../HARDWARE/Arduino-MAX30100-master/src/: MAX30100.cpp MAX30100_BeatDetector.cpp MAX30100_PulseOximeter.cpp MAX30100_SpO2Calculator.cpp
  group Application/User
    ./: stm32f1xx_hal_msp.c stm32f1xx_it.c main.c
