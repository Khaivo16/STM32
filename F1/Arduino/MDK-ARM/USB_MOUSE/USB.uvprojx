# Keil uVision project USB.uvprojx, settings and files
target STM32F4 Configuration (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: F4Cpp +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32F103xG,STM32F1xx,USBD_USE_HID_COMPOSITE,USBCON
  c misc: --cpp11
  c include: ..\..\Inc;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\SYSTEM\delay;..\..\SYSTEM\sys;..\..\SYSTEM\usart;..\USB_KEYBOARD;..\..\HARDWARE;..\..\HARDWARE\DHT11;..\..\HARDWARE\TM1637Display;..\..\HARDWARE\USB;..\..\HARDWARE\USB\cdc;..\..\HARDWARE\USB\hid;..\..\Drivers\STM32_USB_Device_Library\Core\Inc;..\..\HARDWARE\Keyboard\src;..\..\HARDWARE\Mouse\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xg.s
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c
  group LIB
    ../../SYSTEM/: PinMap.c F1Cpp.lib
  group HARDWARE
    ../../HARDWARE/DHT11/: DHT11.cpp
    ../../HARDWARE/TM1637Display/: TM1637Display.cpp
  group USB
    ../../HARDWARE/USB/: usbd_conf.c usbd_desc.c usbd_ep_conf.c usbd_if.c USBSerial.cpp
    ../../HARDWARE/USB/cdc/: cdc_queue.c usbd_cdc.c usbd_cdc_if.c
    ../../Drivers/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../HARDWARE/USB/hid/: usbd_hid_composite.c usbd_hid_composite_if.c
    ../../HARDWARE/Keyboard/src/: Keyboard.cpp
    ../../HARDWARE/Mouse/src/: Mouse.cpp
  group Application/User
    ./: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c
