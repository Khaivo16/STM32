# Keil uVision project ENC28j60.uvprojx, settings and files
target STM32F1 Configuration (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F4Cpp
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32F103xB,STM32F1xx,
  c misc: --cpp11
  c include: ..\..\Inc;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\SYSTEM\delay;..\..\SYSTEM\sys;..\..\SYSTEM\usart;..\ETH_ENC28J60;..\..\HARDWARE;..\..\HARDWARE\DHT11;..\..\HARDWARE\TM1637Display;..\..\HARDWARE\UIPEthernet;..\..\HARDWARE\UIPEthernet\utility;..\..\HARDWARE\MQTT\arduino-mqtt-master\src\;..\..\HARDWARE\MQTT\arduino-mqtt-master\src\lwmqtt;..\..\HARDWARE\MQTT\pubsubclient-master\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f101xg.s
  group LIB
    ../../SYSTEM/: F1Cpp.lib PinMap.c
  group HARDWARE
    ../../HARDWARE/DHT11/: DHT11.cpp
    ../../HARDWARE/TM1637Display/: TM1637Display.cpp
    ../../HARDWARE/MQTT/arduino-mqtt-master/src/lwmqtt/: client.c helpers.c packet.c string.c
    ../../HARDWARE/MQTT/arduino-mqtt-master/src/: MQTTClient.cpp
    ../../HARDWARE/MQTT/pubsubclient-master/src/: PubSubClient.cpp
  group UIPEthernet
    ../../HARDWARE/UIPEthernet/: Dhcp.cpp Dns.cpp UIPClient.cpp UIPEthernet.cpp UIPServer.cpp UIPUdp.cpp
    ../../HARDWARE/UIPEthernet/utility/: Enc28J60Network.cpp mempool.cpp uip_debug.cpp clock-arch.c uip.c uip_arp.c uip_timer.c
  group Application/User
    ./: stm32f1xx_hal_msp.c stm32f1xx_it.c main.c
