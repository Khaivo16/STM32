# Keil uVision project RFID.uvprojx, settings and files
target STM32F1 Configuration (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F1Cpp
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32F103xB,STM32F1xx,
  c misc: --cpp11
  c include: ..\..\Inc;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\SYSTEM\delay;..\..\SYSTEM\sys;..\..\SYSTEM\usart;..\Blink;..\..\HARDWARE;..\..\HARDWARE\DHT11;..\..\HARDWARE\TM1637Display;..\..\HARDWARE\Wire\src;..\..\HARDWARE\LiquidCrystal_I2C-1.1.2;..\..\HARDWARE\rfid\src;..\..\HARDWARE\MFRC522-master
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xg.s
  group LIB
    ../../SYSTEM/: F1Cpp.lib PinMap.c
  group Wire
    ../../HARDWARE/Wire/src/: twi.c Wire.cpp
  group RFID
    ../../HARDWARE/MFRC522-master/: MFRC522.cpp
  group HARDWARE
    ../../HARDWARE/DHT11/: DHT11.cpp
    ../../HARDWARE/TM1637Display/: TM1637Display.cpp
    ../../HARDWARE/LiquidCrystal_I2C-1.1.2/: LiquidCrystal_I2C.cpp
  group Application/User
    ./: stm32f1xx_hal_msp.c stm32f1xx_it.c main.c
