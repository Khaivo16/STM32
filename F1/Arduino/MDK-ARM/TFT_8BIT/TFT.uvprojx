# Keil uVision project TFT.uvprojx, settings and files
target STM32F1 Configuration (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F4Cpp +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32F103xG,STM32F1xx,
  c misc: --cpp
  c include: ..\..\Inc;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\SYSTEM\delay;..\..\SYSTEM\sys;..\..\SYSTEM\usart;..\TFT;..\..\HARDWARE;..\..\HARDWARE\DHT11;..\..\HARDWARE\TM1637Display;..\..\HARDWARE\SD;..\..\HARDWARE\SD\utility;..\..\HARDWARE\Adafruit_GFX_AS;..\..\HARDWARE\Adafruit_GFX_AS\utility;..\..\HARDWARE\Adafruit_ILI9341;..\..\HARDWARE\Adafruit_ILI9341_DMA;..\..\HARDWARE\Adafruit_TFTLCD_8bit_STM32
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xg.s
  group LIB
    ../../SYSTEM/: PinMap.c F1Cpp.lib
  group HARDWARE
    ../../HARDWARE/DHT11/: DHT11.cpp
    ../../HARDWARE/TM1637Display/: TM1637Display.cpp
    ../../HARDWARE/SD/: File.cpp SD.cpp
    ../../HARDWARE/SD/utility/: Sd2Card.cpp SdFile.cpp SdVolume.cpp
    ../../HARDWARE/Adafruit_GFX_AS/: Font7s.c Font16.c Font32.c Font64.c glcdfont.c Adafruit_GFX_AS.cpp
    ../../HARDWARE/Adafruit_GFX_AS/utility/: Adafruit_GFX.cpp
    ../../HARDWARE/Adafruit_ILI9341/: Adafruit_ILI9341.cpp
    ../../HARDWARE/Adafruit_ILI9341_DMA/: Adafruit_ILI9341_DMA.cpp
  group TFT_8BIT
    ../../HARDWARE/Adafruit_TFTLCD_8bit_STM32/: Adafruit_TFTLCD_8bit_STM32.cpp hx8347g.cpp hx8357x.cpp ili932x.cpp ili9341.cpp
  group Application/User
    ./: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c
