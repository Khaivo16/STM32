# Keil uVision project ETHERNET.uvprojx, settings and files
target STM32F4 Configuration (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: F4Cpp +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F4xx,STM32F407xx,USE_FULL_LL_DRIVER
  c misc: --cpp11
  c include: ..\..\Inc;..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\SYSTEM\delay;..\..\SYSTEM\sys;..\..\SYSTEM\usart;..\ETHERNET_STM32;..\..\HARDWARE;..\..\HARDWARE\DHT11;..\..\HARDWARE\TM1637Display;..\..\HARDWARE\LwIP-master\src;..\..\HARDWARE\LwIP-master\src\core;..\..\HARDWARE\LwIP-master\src\core\ipv4;..\..\HARDWARE\LwIP-master\src\core\ipv6;..\..\HARDWARE\LwIP-master\src\lwip;..\..\HARDWARE\LwIP-master\src\lwip\apps;..\..\HARDWARE\LwIP-master\src\lwip\priv;..\..\HARDWARE\LwIP-master\src\lwip\prot;..\..\HARDWARE\LwIP-master\src\netif;..\..\HARDWARE\STM32Ethernet-master\src;..\..\HARDWARE\STM32Ethernet-master\src\utility;..\..\HARDWARE\MQTT\arduino-mqtt-master\src;..\..\HARDWARE\MQTT\arduino-mqtt-master\src\lwmqtt;..\..\HARDWARE\MQTT\pubsubclient-master\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_eth.c
  group LIB
    ../../SYSTEM/: F4Cpp.lib PinMap.c
  group HARDWARE
    ../../HARDWARE/DHT11/: DHT11.cpp
    ../../HARDWARE/TM1637Display/: TM1637Display.cpp
  group LWIP
    ../../HARDWARE/LwIP-master/src/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c sys_arch.c tcpip.c
    ../../HARDWARE/LwIP-master/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../HARDWARE/LwIP-master/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../HARDWARE/LwIP-master/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../HARDWARE/LwIP-master/src/netif/: arc4.c auth.c bridgeif.c bridgeif_fdb.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c des.c eap.c ecp.c ethernet.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c lowpan6.c lowpan6_ble.c lowpan6_common.c magic.c md4.c md5.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c sha1.c upap.c utils.c vj.c zepif.c
  group ETHERNET
    ../../HARDWARE/STM32Ethernet-master/src/: Dhcp.cpp Dns.cpp EthernetClient.cpp EthernetServer.cpp EthernetUdp.cpp STM32Ethernet.cpp
    ../../HARDWARE/STM32Ethernet-master/src/utility/: ethernetif.cpp
  group MQTT
    ../../HARDWARE/MQTT/pubsubclient-master/src/: PubSubClient.cpp
  group Application/User
    ./: stm32f4xx_hal_msp.c stm32f4xx_it.c main.c
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
