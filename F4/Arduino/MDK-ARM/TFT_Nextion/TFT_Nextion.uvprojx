# Keil uVision project TFT_Nextion.uvprojx, settings and files
target STM32F4 Configuration (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: F4Cpp
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --cpp
  c include: ..\..\Inc;..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\SYSTEM\delay;..\..\SYSTEM\sys;..\..\SYSTEM\usart;..\Blink;..\..\HARDWARE;..\..\HARDWARE\DHT11;..\..\HARDWARE\TM1637Display;..\..\HARDWARE\TFT_Arduino_Nextion-master;..\..\HARDWARE\SD;..\..\HARDWARE\SD\utility
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c
  group LIB
    ../../SYSTEM/: PinMap.c F4Cpp.lib
  group HARDWARE
    ../../HARDWARE/DHT11/: DHT11.cpp
    ../../HARDWARE/TM1637Display/: TM1637Display.cpp
  group SD
    ../../HARDWARE/SD/: File.cpp SD.cpp
    ../../HARDWARE/SD/utility/: Sd2Card.cpp SdFile.cpp SdVolume.cpp
  group TFT_Nextion
    ../../HARDWARE/TFT_Arduino_Nextion-master/: NexButton.cpp NexCheckbox.cpp NexCrop.cpp NexDualStateButton.cpp NexGauge.cpp NexGpio.cpp NexHardware.cpp NexHotspot.cpp NexNumber.cpp NexObject.cpp NexPage.cpp NexPicture.cpp NexProgressBar.cpp NexRadio.cpp NexRtc.cpp NexScrolltext.cpp NexSlider.cpp NexText.cpp NexTimer.cpp NexTouch.cpp NexUpload.cpp NexVariable.cpp NexWaveform.cpp
  group Application/User
    ./: stm32f4xx_it.c stm32f4xx_hal_msp.c main.c
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
