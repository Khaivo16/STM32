# Keil uVision project TFT.uvprojx, settings and files
target STM32F4 Configuration (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: F4Cpp +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F4xx,STM32F407xx
  c misc: --cpp
  c include: ..\..\Inc;..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\SYSTEM\delay;..\..\SYSTEM\sys;..\..\SYSTEM\usart;..\TFT;..\..\HARDWARE;..\..\HARDWARE\DHT11;..\..\HARDWARE\TM1637Display;..\..\HARDWARE\SD;..\..\HARDWARE\SD\utility;..\..\HARDWARE\Adafruit_GFX_AS;..\..\HARDWARE\Adafruit_GFX_AS\utility;..\..\HARDWARE\Adafruit_ILI9341;..\..\HARDWARE\Adafruit_ILI9341_DMA;..\..\HARDWARE\Adafruit_TFTLCD_16bit_STM32-FSMC\src;..\..\HARDWARE\XPT2046_touch\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c
  group LIB
    ../../SYSTEM/: F4Cpp.lib PinMap.c
  group HARDWARE
    ../../HARDWARE/DHT11/: DHT11.cpp
    ../../HARDWARE/TM1637Display/: TM1637Display.cpp
    ../../HARDWARE/SD/: File.cpp SD.cpp
    ../../HARDWARE/SD/utility/: Sd2Card.cpp SdFile.cpp SdVolume.cpp
    ../../HARDWARE/Adafruit_GFX_AS/: Font7s.c Font16.c Font32.c Font64.c glcdfont.c Adafruit_GFX_AS.cpp
    ../../HARDWARE/Adafruit_GFX_AS/utility/: Adafruit_GFX.cpp
    ../../HARDWARE/Adafruit_ILI9341/: Adafruit_ILI9341.cpp
    ../../HARDWARE/Adafruit_ILI9341_DMA/: Adafruit_ILI9341_DMA.cpp
  group TFT_FSMC
    ../../HARDWARE/Adafruit_TFTLCD_16bit_STM32-FSMC/src/: Adafruit_TFTLCD_16bit_STM32.cpp hx8347g.cpp hx8357x.cpp ili932x.cpp ili9341.cpp
  group Application/User
    ./: stm32f4xx_hal_msp.c stm32f4xx_it.c main.c
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
