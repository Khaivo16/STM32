# Keil uVision project SD.uvprojx, settings and files
target STM32F4 Configuration (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: F4Cpp
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F4xx,STM32F407xx,SDIO
  c misc: --cpp
  c include: ..\..\Inc;..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\SYSTEM\delay;..\..\SYSTEM\sys;..\..\SYSTEM\usart;..\SDIO;..\..\HARDWARE;..\..\HARDWARE\DHT11;..\..\HARDWARE\TM1637Display;..\..\HARDWARE\SDIO\src;..\..\HARDWARE\SDIO\src\FATFs
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_sd.c stm32f4xx_hal_mmc.c stm32f4xx_ll_sdmmc.c
  group LIB
    ../../SYSTEM/: PinMap.c F4Cpp.lib
  group HARDWARE
    ../../HARDWARE/DHT11/: DHT11.cpp
    ../../HARDWARE/TM1637Display/: TM1637Display.cpp
    ../../HARDWARE/SDIO/src/: bsp_sd.c SD.cpp Sd2Card.cpp SdFatFs.cpp
  group FATFs
    ../../HARDWARE/SDIO/src/FATFs/: cc932.c cc936.c cc949.c cc950.c ccsbcs.c diskio.c ff.c ff_gen_drv.c sd_diskio.c syscall.c
  group Application/User
    ./: stm32f4xx_hal_msp.c stm32f4xx_it.c main.c
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
